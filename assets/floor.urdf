Commit message: Adjust so dino doesn't fall off the edge.

File: assets/floor.urdf (robot description, URDF)
Before this commit: robot cube.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=1000 1000 0.001; visual mesh filename=plane.obj scale=1 1 1
